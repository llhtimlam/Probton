VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;

MACRO analog_readout
  CLASS BLOCK ;
  SIZE 10 BY 10 ;
  SYMMETRY X Y ;
END analog_readout

MACRO analog_wave_mixer
  CLASS BLOCK ;
  SIZE 10 BY 10 ;
  SYMMETRY X Y ;
END analog_wave_mixer

MACRO analog_comp
  CLASS BLOCK ;
  SIZE 10 BY 10 ;
  SYMMETRY X Y ;
END analog_comp

END LIBRARY